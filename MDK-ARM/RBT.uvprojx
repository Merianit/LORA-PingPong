# Keil uVision project RBT.uvprojx, settings and files
target RBT (6180000::V6.18::ARMCLANG)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: RBT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L152xB
  c include: ../Core/Inc;  ../Drivers/STM32L1xx_HAL_Driver/Inc;  ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;  ../Drivers/CMSIS/Include;  ../Libs/Common/Inc;  ../Libs/Display/Inc;  ../Libs/Keyboard/Key/Inc;  ../Libs/Keyboard/Keypad/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l152xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Libs
    ../Libs/Common/Src/: Common.c
    ../Libs/Display/Src/: st7735.c font8.c font12.c font16.c font20.c font24.c st7735_test.c
    ../Libs/Keyboard/Key/Src/: Key.c
    ../Libs/Keyboard/Keypad/Src/: Keypad.c
software components: CMSIS:CORE 5.6.0
